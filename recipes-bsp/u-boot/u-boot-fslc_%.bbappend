DEPENDS_append = " u-boot-scr"